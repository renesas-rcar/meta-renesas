include core-image-renesas-base.inc
