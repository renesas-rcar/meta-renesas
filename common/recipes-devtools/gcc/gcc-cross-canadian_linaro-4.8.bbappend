INSANE_SKIP_${PN} += "libdir"
