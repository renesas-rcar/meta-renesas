PRIVATE_LIBS_${PN} = "libgstcoreelements.so"
