DEPENDS += "gst-plugins-ugly"
PRINC := "${@int(PRINC) + 1}"
