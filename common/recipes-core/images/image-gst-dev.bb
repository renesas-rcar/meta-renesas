require image-gst.bb

IMAGE_FEATURES += "dev-pkgs"
