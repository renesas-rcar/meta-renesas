require qt4_append.inc