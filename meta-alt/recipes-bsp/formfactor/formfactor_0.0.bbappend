FILESEXTRAPATHS_prepend_alt := "${THISDIR}/${PN}:"
