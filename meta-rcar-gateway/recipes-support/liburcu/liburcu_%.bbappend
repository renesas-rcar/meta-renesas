# WORKAROUND for compile error
CFLAGS_remove_rcar-gateway = "-O2"
CFLAGS_append_rcar-gateway = "-O0"
