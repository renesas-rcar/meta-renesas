RDEPENDS_${PN} += " \
    nativesdk-cmake \
"
