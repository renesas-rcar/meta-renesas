PV = "1.1.1o"
SRC_URI[sha256sum] = "9384a2b0570dd80358841464677115df785edb941c71211f75076d72fe6b438f"
SRC_URI_remove = "file://CVE-2023-0464.patch \
                  file://CVE-2023-0465.patch \
                  file://CVE-2023-0466.patch \
                  "
