# Add support nativesdk
BBCLASSEXTEND_append_rcar-gen5 = " nativesdk"
