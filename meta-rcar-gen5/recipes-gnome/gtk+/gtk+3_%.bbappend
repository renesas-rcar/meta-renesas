PACKAGECONFIG_remove_rcar-gen5 = "wayland"
