FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI_append = " file://0001-rpmio-macro-Don-t-point-before-the-buffer-in-rdcl.patch"
