SRC_URI = "git://git.yoctoproject.org/pseudo;branch=master;protocol=https \
           file://fallback-passwd \
           file://fallback-group \
           "
SRCREV = "823895ba708c63f6ae4dcbfc266210f26c02c698"
PV = "1.9.8"
