DESCRIPTION = "A small image just capable of allowing a device to boot and \
is suitable for development work."

require rcar-image-minimal.bb
require include/rcar-image-dev.inc
