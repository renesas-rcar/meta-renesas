RDEPENDS:${PN}:remove = "wayland-utils"
IMAGE_INSTALL:remove = "wayland-utils"

