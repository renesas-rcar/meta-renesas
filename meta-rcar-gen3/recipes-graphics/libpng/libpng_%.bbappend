# ...use neon acceleration
EXTRA_OECONF_append_aarch64 = " --enable-arm-neon=on"
