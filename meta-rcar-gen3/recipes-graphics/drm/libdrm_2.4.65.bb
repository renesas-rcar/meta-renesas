require recipes-graphics/drm/libdrm.inc

SRC_URI += "file://installtests.patch "

SRC_URI[md5sum] = "de49916e5f8aef4eba55223c79709b05"
SRC_URI[sha256sum] = "71960ac8bde7d710992b1bc8879935e8300a870c36bd06f22412d0447e3d96c4"
