# Update URL for ccache
SRC_URI_remove = "git://git.samba.org/ccache.git"
SRC_URI_append = " git://github.com/ccache/ccache.git"
