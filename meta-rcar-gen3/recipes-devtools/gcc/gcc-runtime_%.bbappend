require gcc-multilib-config.inc

FILES_libstdc++-dev += " \
    ${libdir}/libstdc++fs.la \
"

FILES_libstdc++-staticdev += " \
    ${libdir}/libstdc++fs.a \
"
