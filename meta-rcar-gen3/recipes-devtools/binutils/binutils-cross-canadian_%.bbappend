inherit cross-canadian-multilib
