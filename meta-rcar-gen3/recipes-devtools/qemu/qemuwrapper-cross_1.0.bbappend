QEMU_OPTIONS_aarch64 = "-r 3.7.0"
