# nativesdk don't generally look in base_libdir
base_libdir:class-nativesdk = "${libdir}"
