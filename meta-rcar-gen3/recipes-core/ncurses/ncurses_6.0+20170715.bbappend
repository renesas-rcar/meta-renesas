# nativesdk don't generally look in base_libdir
base_libdir_class-nativesdk = "${libdir}"
