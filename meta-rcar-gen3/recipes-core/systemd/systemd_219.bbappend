EXTRA_OECONF += " \
    --disable-timesyncd \
"
