# Add support nativesdk
BBCLASSEXTEND_append_rcar-gen3 = " nativesdk"
