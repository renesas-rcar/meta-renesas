INSANE_SKIP_${PN} += "textrel"
