FILESEXTRAPATHS_prepend_bockw := "${THISDIR}/${PN}:"

PRINC = "1"
