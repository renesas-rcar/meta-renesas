IMAGE_INSTALL += " \
    alsa-utils alsa-tools \
"
