PRINC := "${@int(PRINC) + 10}"

SRCREV = "a4fb49cbfcb1d5f475ba4407807834b1a820a261"
SRC_URI = "git://git.denx.de/u-boot-sh.git;branch=renesas/bsp/rcar-gen2-5.6;protocol=git"
