FILESEXTRAPATHS_prepend_koelsch := "${THISDIR}/${PN}:"

PRINC = "1"
