PRINC := "${@int(PRINC) + 11}"

SRCREV = "1568d0fe1d00675d79c0bc1dd8f8ec64e2ab766c"
SRC_URI = "git://git.denx.de/u-boot-sh.git;branch=renesas/bsp/rcar-gen2-7;protocol=git"
