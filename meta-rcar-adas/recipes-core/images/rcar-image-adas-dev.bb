DESCRIPTION = "A image with support for ADAS applications and is suitable \
for development work."

require rcar-image-adas.bb
require include/rcar-image-dev.inc
