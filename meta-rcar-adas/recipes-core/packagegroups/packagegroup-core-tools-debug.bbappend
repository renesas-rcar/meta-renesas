# Due to compile error with Kernel 5.10.41, strace will be temporary
# removed
RDEPENDS:${PN}:remove:rcar-v4x = "${STRACE}"
