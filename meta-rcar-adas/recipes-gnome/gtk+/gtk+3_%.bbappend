PACKAGECONFIG:remove:rcar-v4x = "wayland"
