# Add support nativesdk
BBCLASSEXTEND:append:rcar = " nativesdk"
