# Add support nativesdk
BBCLASSEXTEND_append_rcar = " nativesdk"
