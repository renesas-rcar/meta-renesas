# WORKAROUND for compile error
CFLAGS:remove = "-O2"
CFLAGS:append = " -O0"
