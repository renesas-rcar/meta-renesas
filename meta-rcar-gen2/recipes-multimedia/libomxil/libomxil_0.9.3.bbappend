do_populate_sysroot () {
	rm -f ${D}/usr/include/*.h
}
