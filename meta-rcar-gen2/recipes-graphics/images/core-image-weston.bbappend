include core-image-weston.inc

