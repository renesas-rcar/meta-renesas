SRC_URI = " \
    http://downloads.yoctoproject.org/mirror/sources/${BP}.tar.bz2 \
    file://Module.mk \
"
