DEPENDS += "v4l-utils"
PRINC := "${@int(PRINC) + 1}"
