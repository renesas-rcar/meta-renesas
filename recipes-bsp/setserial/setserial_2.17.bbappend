INSANE_SKIP_setserial += "ldflags"
