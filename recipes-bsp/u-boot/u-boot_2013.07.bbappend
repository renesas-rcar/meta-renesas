PRINC := "${@int(PRINC) + 1}"

SRCREV = "52654d58a05da44fa65cad6caae806cd87ba2b07"
SRC_URI = "git://git.denx.de/u-boot-sh.git;branch=bsp/lager;protocol=git"
